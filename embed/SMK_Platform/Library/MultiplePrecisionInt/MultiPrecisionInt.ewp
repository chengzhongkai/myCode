# IAR project MultiPrecisionInt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64xX512xxx12 Freescale MK64xX512xxx12
  ICCARM.CCDefines: __FREESCALE_MQX__; DEBUG_LEVEL=2
  ICCARM.CCDiagSuppress: Pe082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ; ../../MQX/lib/SMK_Gateway.iar/debug/bsp/Generated_Code; ../../MQX/lib/SMK_Gateway.iar/debug/bsp/Sources; ../../MQX/lib/SMK_Gateway.iar/debug; ../../MQX/lib/SMK_Gateway.iar/debug/bsp; ../../MQX/lib/SMK_Gateway.iar/debug/psp; ../../MQX/lib/SMK_Gateway.iar/debug/mfs; ../../MQX/lib/SMK_Gateway.iar/debug/rtcs; ../../MQX/lib/SMK_Gateway.iar/debug/shell; ../../Platform/src; ../../Platform/src/cau
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../..; ../../lib/SMK_Gateway.iar/debug/bsp/Generated_Code; ../../lib/SMK_Gateway.iar/debug/bsp/Sources; ../../lib/SMK_Gateway.iar/debug; ../../lib/SMK_Gateway.iar/debug/bsp; ../../lib/SMK_Gateway.iar/debug/psp; ../../lib/SMK_Gateway.iar/debug/mfs; ../../lib/SMK_Gateway.iar/debug/rtcs; ../../lib/SMK_Gateway.iar/debug/shell
  ILINK.IlinkOutputFile: Platform.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Source
    ./: aldec.c alinc.c alsub.c aux1.c det.c iset.c ladd.c larrayread.c larrayset.c lcmp.c ldec.c ldisp.c ldiv.c ldown.c lfactor.c lgcd.c linc.c linv.c lkaijo.c llcm.c llgcd.c lllcm.c lmod.c lmul.c lmul1.c lmulp.c longint.h lprime_chk.c lpwr.c lpwrmod.c lread.c lrnd.c lrnd1.c lset.c lsqr.c lsqrt.c lsub.c lswap.c lup.c lwrite.c sadd.c sdiv.c sdiv1.c smod.c smul.c smul1.c ssub.c
