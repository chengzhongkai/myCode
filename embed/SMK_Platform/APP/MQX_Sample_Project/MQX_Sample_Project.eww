<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\Library\EchonetLiteLite\EchonetLiteLite.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Bootloader\targets\k64f12\iar\freedom_bootloader\freedom_bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Library\HaControl\HaControl.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MQX_Sample_Project.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Platform\Platform.ewp</path>
  </project>
  <batchBuild/>
</workspace>


