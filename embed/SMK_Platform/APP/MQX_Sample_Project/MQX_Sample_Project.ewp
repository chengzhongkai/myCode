# IAR project MQX_Sample_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64xX512xxx12 Freescale MK64xX512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __FREESCALE_MQX__; DEBUG_LEVEL=2
  ICCARM.CCDiagSuppress: Pe082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: $PROJ_DIR$; shell; ../../MQX/lib/SMK_Gateway.iar/debug/bsp/Generated_Code; ../../MQX/lib/SMK_Gateway.iar/debug/bsp/Sources; ../../MQX/lib/SMK_Gateway.iar/debug; ../../MQX/lib/SMK_Gateway.iar/debug/bsp; ../../MQX/lib/SMK_Gateway.iar/debug/psp; ../../MQX/lib/SMK_Gateway.iar/debug/mfs; ../../MQX/lib/SMK_Gateway.iar/debug/rtcs; ../../MQX/lib/SMK_Gateway.iar/debug/shell; ../../Platform/src; ../../Platform/src/cau; ../../Library/EchonetLiteLite/include; ../../Library/HaControl; ../../Library/WebSocket; ../../Library/TLS; ../../Library/MQTT
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../..; ../../MQX/lib/SMK_Gateway.iar/debug/bsp/Generated_Code; ../../MQX/lib/SMK_Gateway.iar/debug/bsp/Sources; ../../MQX/lib/SMK_Gateway.iar/debug; ../../MQX/lib/SMK_Gateway.iar/debug/bsp; ../../MQX/lib/SMK_Gateway.iar/debug/psp; ../../MQX/lib/SMK_Gateway.iar/debug/mfs; ../../MQX/lib/SMK_Gateway.iar/debug/rtcs; ../../MQX/lib/SMK_Gateway.iar/debug/shell
  OBJCOPY.OOCOutputFile: MQX_Sample_Project.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkIcfFile: ..\..\MQX\lib\SMK_Gateway.iar\debug\bsp\intflash_boot.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../MQX/lib/SMK_Gateway.iar/debug/bsp/bsp.a; ../../MQX/lib/SMK_Gateway.iar/debug/psp/psp.a; ../../MQX/lib/SMK_Gateway.iar/debug/mfs/mfs.a; ../../MQX/lib/SMK_Gateway.iar/debug/rtcs/rtcs.a; ../../MQX/lib/SMK_Gateway.iar/debug/shell/shell.a; ../../Platform/Debug/Exe/Platform.a; ../../Library/EchonetLiteLite/Debug/Exe/EchonetLiteLite.a; ../../Library/HaControl/Debug/Exe/HaControl.a; ../../Library/WebSocket/Debug/Exe/WebSocket.a; ../../Library/TLS/Debug/Exe/TLS.a; ../../Library/MQTT/Debug/Exe/MQTT.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: ell_app.c ell_app.h ell_app_ctlr.c ell_app_ha_x2.c ell_gateway.c ell_task.c ell_task.h mdns.c mdns.h mqtt_task.c mqtt_task.h mwa_task.c
  group MQX_Libraries
    ../../MQX/lib/SMK_Gateway.iar/debug/bsp/: bsp.a
    ../../MQX/lib/SMK_Gateway.iar/debug/psp/: psp.a
  group MSF_Libraries
    ../../MQX/lib/SMK_Gateway.iar/debug/mfs/: mfs.a
  group Platform_Libraries
    ../../Platform/Debug/Exe/: Platform.a
  group RTCS_Libraries
    ../../MQX/lib/SMK_Gateway.iar/debug/rtcs/: rtcs.a
  group Source
    ./: Config.h console_task.c console_task.h flash_utils.c flash_utils.h Init_Task.c led_task.c led_task.h Tasks.c Tasks.h Telnet.c Telnet.h version.c
  group Source/CAU
    cau/: cau_api.h lib_mmcau.a
  group Source/http_server
    http_server/: tfs_data.c web.c web.h
  group Source/shell
    shell/: sh_cloud.c sh_debug.c sh_dns.c sh_eeprom.c sh_enet.c sh_info.c sh_mqtt.c sh_reset.c sh_test.c sh_update.c sh_version.c shell_command.h
