<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iar\freedom_bootloader\freedom_bootloader.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All configurations</name>
      <member>
        <project>freedom_bootloader</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>freedom_bootloader</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


