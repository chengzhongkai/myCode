# IAR project freedom_bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64xX512xxx12 Freescale MK64xX512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MK64FN1M0VMD12; BL_TARGET_FLASH
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\startup; ..\..\..\..\src\autobaud; ..\..\..\..\src\drivers\uart; ..\..\..\..\src\drivers\mcg; ..\..\..\..\src\usb_device\driver; ..\..\..\..\src\usb_device\driver\kinetis; ..\..\..\..\src\usb_device\common; ..\..\..\..\src\usb_device\class; ..\..\..\..\src\usb_device\hid; ..\..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: BL_TARGET_FLASH
  AARM.AUserIncludes: ..\..\..\..\src\include
  OBJCOPY.OOCOutputFile: freedom_bootloader.bin
  ILINK.IlinkOutputFile: freedom_bootloader.out
  ILINK.IlinkIcfFile: ..\..\..\common\iar\config\1MB_Pflash_256KB_RAM_low_bootloader.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  ICCARM.CCDefines: FREEDOM; CPU_MK64FN1M0VMD12; NDEBUG; BL_TARGET_FLASH
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\src; ..\..\..\..\src\autobaud; ..\..\..\..\src\drivers; ..\..\..\..\src\common; ..\..\..\..\src\startup; ..\..\..\..\src\drivers\uart; ..\..\..\..\src\drivers\mcg; ..\..\..\..\src\platforms; ..\..\..\..\src\usb_device\driver; ..\..\..\..\src\usb_device\driver\kinetis; ..\..\..\..\src\usb_device\common; ..\..\..\..\src\usb_device\class; ..\..\..\..\src\usb_device\hid; ..\..\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group k64f12
    ../../src/: bootloader_config.h hardware_init_MK64F12.c
  group link
    ../../../common/iar/config/: 1MB_Pflash_256KB_RAM_low_bootloader.icf
  group src/bootloader
    ../../../../src/bootloader/: bootloader_eeprom.h bootloader_led.h bootloader_update.h shutdown_cleanup.h
  group src/bootloader/src
    ../../../../src/bootloader/src/: bootloader.c bootloader_eeprom.c bootloader_led.c bootloader_update.c shutdown_cleanup.c
  group src/drivers/dspi
    ../../../../src/drivers/dspi/: fsl_dspi_types.h
  group src/drivers/dspi/hal
    ../../../../src/drivers/dspi/hal/: fsl_dspi_features.h fsl_dspi_hal.c fsl_dspi_hal.h
  group src/drivers/dspi/src
    ../../../../src/drivers/dspi/src/: fsl_dspi_shared_irqs.c
  group src/drivers/flash
    ../../../../src/drivers/flash/: flash.h
    ../../../../src/drivers/flash/src/: flash_command_sequence.c flash_densities_k_series.c flash_erase.c flash_erase_all.c flash_erase_all_unsecure.c flash_get_property.c flash_get_security_state.c flash_init.c flash_is_protected.c flash_program.c flash_security_bypass.c flash_verify_erase.c flash_verify_erase_all.c flash_verify_program.c SSD_FTFx_Common.h
  group src/drivers/flextimer/hal
    ../../../../src/drivers/flextimer/hal/: fsl_ftm_features.h fsl_ftm_hal.c fsl_ftm_hal.h
  group src/drivers/microseconds
    ../../../../src/drivers/microseconds/: microseconds.h
  group src/drivers/microseconds/src
    ../../../../src/drivers/microseconds/src/: microseconds_sysclk.c
  group src/drivers/uart
    ../../../../src/drivers/uart/: scuart.c scuart.h
  group src/include
    ../../../../src/include/: bootloader_common.h fsl_platform_common.h fsl_platform_status.h fsl_platform_types.h
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../../../../src/startup/MK64F12/iar/: startup_MK64F12.s
    ../../src/: system_MK64F12.c
  group src/utilities
    ../../../../src/utilities/src/: fsl_rtos_abstraction.c
    ../../../../src/utilities/: fsl_rtos_abstraction.h
