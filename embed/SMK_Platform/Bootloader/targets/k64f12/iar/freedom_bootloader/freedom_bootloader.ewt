<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>k64f12</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\bootloader_config.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\hardware_init_MK64F12.c</name>
    </file>
  </group>
  <group>
    <name>link</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\common\iar\config\1MB_Pflash_256KB_RAM_low_bootloader.icf</name>
    </file>
  </group>
  <group>
    <name>src</name>
    <group>
      <name>bootloader</name>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\bootloader\src\bootloader.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\bootloader\src\bootloader_eeprom.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\bootloader\src\bootloader_led.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\bootloader\src\bootloader_update.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\bootloader\src\shutdown_cleanup.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\bootloader\bootloader_eeprom.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\bootloader\bootloader_led.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\bootloader\bootloader_update.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\bootloader\shutdown_cleanup.h</name>
      </file>
    </group>
    <group>
      <name>drivers</name>
      <group>
        <name>dspi</name>
        <group>
          <name>hal</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\src\drivers\dspi\hal\fsl_dspi_features.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\src\drivers\dspi\hal\fsl_dspi_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\src\drivers\dspi\hal\fsl_dspi_hal.h</name>
          </file>
        </group>
        <group>
          <name>src</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\src\drivers\dspi\src\fsl_dspi_shared_irqs.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\dspi\fsl_dspi_types.h</name>
        </file>
      </group>
      <group>
        <name>flash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\flash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_command_sequence.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_densities_k_series.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_erase.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_erase_all.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_erase_all_unsecure.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_get_property.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_get_security_state.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_init.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_is_protected.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_program.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_security_bypass.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_verify_erase.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_verify_erase_all.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_verify_program.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\SSD_FTFx_Common.h</name>
        </file>
      </group>
      <group>
        <name>flextimer</name>
        <group>
          <name>hal</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\src\drivers\flextimer\hal\fsl_ftm_features.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\src\drivers\flextimer\hal\fsl_ftm_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\src\drivers\flextimer\hal\fsl_ftm_hal.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>microseconds</name>
        <group>
          <name>src</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\src\drivers\microseconds\src\microseconds_sysclk.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\microseconds\microseconds.h</name>
        </file>
      </group>
      <group>
        <name>uart</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\uart\scuart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\uart\scuart.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\include\bootloader_common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\include\fsl_platform_common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\include\fsl_platform_status.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\include\fsl_platform_types.h</name>
      </file>
    </group>
    <group>
      <name>startup</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\startup\crt0.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\startup\startup.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\startup\MK64F12\iar\startup_MK64F12.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\system_MK64F12.c</name>
      </file>
    </group>
    <group>
      <name>utilities</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\utilities\src\fsl_rtos_abstraction.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\utilities\fsl_rtos_abstraction.h</name>
      </file>
    </group>
  </group>
</project>


