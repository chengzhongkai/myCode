<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\mqx\build\iar\bsp_SMK_Gateway\bsp_SMK_Gateway.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\mfs\build\iar\mfs_SMK_Gateway\mfs_SMK_Gateway.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\mqx\build\iar\psp_SMK_Gateway\psp_SMK_Gateway.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\rtcs\build\iar\rtcs_SMK_Gateway\rtcs_SMK_Gateway.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\shell\build\iar\shell_SMK_Gateway\shell_SMK_Gateway.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>bsp_SMK_Gateway</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bsp_SMK_Gateway</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mfs_SMK_Gateway</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mfs_SMK_Gateway</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>psp_SMK_Gateway</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>psp_SMK_Gateway</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>rtcs_SMK_Gateway</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>rtcs_SMK_Gateway</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>shell_SMK_Gateway</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>shell_SMK_Gateway</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>bsp_SMK_Gateway</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mfs_SMK_Gateway</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>psp_SMK_Gateway</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>rtcs_SMK_Gateway</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>shell_SMK_Gateway</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>msg_EchonetBoard</project>
        <configuration>Int Flash Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>bsp_SMK_Gateway</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mfs_SMK_Gateway</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>psp_SMK_Gateway</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>rtcs_SMK_Gateway</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>shell_SMK_Gateway</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>msg_EchonetBoard</project>
        <configuration>Int Flash Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


