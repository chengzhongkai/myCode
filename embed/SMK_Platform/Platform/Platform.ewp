# IAR project Platform.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64xX512xxx12 Freescale MK64xX512xxx12
  ICCARM.CCDefines: DEBUG_LEVEL=1; __FREESCALE_MQX__
  ICCARM.CCDiagSuppress: Pe082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ; ../MQX/lib/SMK_Gateway.iar/debug/bsp/Generated_Code; ../MQX/lib/SMK_Gateway.iar/debug/bsp/Sources; ../MQX/lib/SMK_Gateway.iar/debug; ../MQX/lib/SMK_Gateway.iar/debug/bsp; ../MQX/lib/SMK_Gateway.iar/debug/psp; ../MQX/lib/SMK_Gateway.iar/debug/mfs; ../MQX/lib/SMK_Gateway.iar/debug/rtcs; ../MQX/lib/SMK_Gateway.iar/debug/shell; src/cau
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../..; ../../lib/SMK_Gateway.iar/debug/bsp/Generated_Code; ../../lib/SMK_Gateway.iar/debug/bsp/Sources; ../../lib/SMK_Gateway.iar/debug; ../../lib/SMK_Gateway.iar/debug/bsp; ../../lib/SMK_Gateway.iar/debug/psp; ../../lib/SMK_Gateway.iar/debug/mfs; ../../lib/SMK_Gateway.iar/debug/rtcs; ../../lib/SMK_Gateway.iar/debug/shell
  ILINK.IlinkOutputFile: Platform.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CAU
    src/cau/: cau_api.h lib_mmcau.a
  group Platform
    src/: aes.c aes.h base64.c base64.h bignum.c bignum.h debug_log.c debug_log.h des.c des.h DHCP_monitoring.c DNS_Resolver.c DNS_Resolver.h eeprom_api.c eeprom_api.h eeprom_device.c eeprom_device.h FTPClient.c FTPClient.h hash.c hash.h hmac.c hmac.h mqx_utils.c mqx_utils.h multicastsocket_init.c multicastsocket_init.h NetConnect.c NetConnect.h platform.h rand.c rand.h sha1.c sha1.h spi_memory.c spi_memory.h storage_api.c storage_api.h uuid.c uuid.h
